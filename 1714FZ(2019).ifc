Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-04-08T15:31:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 08 15:31:29 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{EDBF339B-65BB-401B-A4FA-4206694BE214}\ifc * Database version: 5507 * Database creation date: Wed Apr 08 15:31:28 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 08 15:31:29 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 08 15:31:29 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 1714FZ Washbasin faucet, 6 V, Bluetooth, 1714FZ(2019):1714FZ Washbasin faucet, 6 V, Bluetooth:323194
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; Projection: 85 mm
Type - Electrical(Type) - Battery: Lithium 2CR5 6 V; Bluetooth: 4.x; Electronic Parts: Autofocus sensor;Solenoid valve;Low battery indication; Operating Voltage: 6 V
Type - General(Type) - Author: Convergo AB; BIMObjectName: 1714FZ(2019); ConvergoRefNr: 0087-2003-0003-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 02/04/2020
Type - Green Building Properties(Type) - Approval GDV-Danmark: 04/00225; Backflow Prevention EN1717: AA; Customs Code: 84818011; EAN Number: 6414150094156; EMC Directive: 2014/30/EU; EN Standard: EN 15091; LVI Number: 6110285; Noise Class: I (ISO 3822); NRF Number: 4203691; RSK Number: 8430595; URL GDV Danmark: http://static.oras.com/GDVDanmark/1714FZ; VVS Number: 704264204
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/1714FZ; Catalog Drawing URL: http://static.oras.com/catdrw/1714FZ; Class: Touchless; Bluetooth®; Battery-operated; Dimension Drawing URL: http://static.oras.com/dimdrw/1714FZ; FDV Document URL: http://www.oras.com/datasheet/1714FZ/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1714FZ; Group: Washbasin Faucets; Manufacturer: Oras; Market: FIN;NOR;SWE;DNK;POL;EST;LTU; Model: 1714FZ Washbasin faucet, 6 V, Bluetooth; Name_en: 1714FZ Washbasin faucet, 6 V, Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 290 x 210 x 90; Package Weight: 1.1 kg; Product Code: 1714FZ; Product Datasheet: http://www.oras.com/datasheet/1714FZ/en; Product Family: Oras Optima; Product Image URL: http://static.oras.com/image/1714FZ; Product URL: http://static.oras.com/1714FZ; Type Name: 1714FZ Washbasin faucet, 6 V, Bluetooth; Usage Group: Offices, personnel sanitary facilities;Hospitals;Households
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: Adjustable settings (via bluetooth); Aerator: HONEYCOMB®;CACHÉ® integrated aerator; Afterflow Period: 3; Automatic Flush: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Connection: Flexible Inlet Pipes; Connection Size: G3/8; Flow Rate At 300kPa With Flow Controller: 0.00282517 m3/s; Installation and Maintenance: http://static.oras.com/manual/1714FZ; Installation Type: Deck mounted; Lever Handle: Temperature control handle; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 120; Mechanical Parts: Mixing valve;Non-return valve(s);Litter filter(s); Mounting Holes: 1 Mounting Hole; Pressure Loss With Flow 01ls: 200000 Pa; Protection Class: IP 55; Spare Parts: http://static.oras.com/sp/1714FZ; Spout Type: Fixed spout; Temperature: Temperature limiter (retrofittable)
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: Single lever; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1714FZ(2019); Features: Touchless; Bluetooth®; Battery-operated; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1714FZ; Name: 1714FZ Washbasin faucet, 6 V, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: 70x135x125 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 1714FZ; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 1714FZ Washbasin faucet, 6 V, Bluetooth
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0360445 m2; Volume: 0.00117752 m3
Identity Data - Mark: 3
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 1714FZ(2019): 1714FZ Washbasin faucet, 6 V, Bluetooth; Family and Type: 1714FZ(2019): 1714FZ Washbasin faucet, 6 V, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1714FZ(2019): 1714FZ Washbasin faucet, 6 V, Bluetooth; Type Id: 1714FZ(2019): 1714FZ Washbasin faucet, 6 V, Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
